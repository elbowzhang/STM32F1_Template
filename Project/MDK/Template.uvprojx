# Keil uVision project Template.uvprojx, settings and files
target STM32F10x (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\USER_Inc;..\..\STM32F10x_StdPeriph_Driver\inc;..\..\CMSIS\CM3\CoreSupport;..\..\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group STM32F10x_StdPeriph_Driver
    ../../STM32F10x_StdPeriph_Driver/src/: misc.c
  group BSP_C
    ../USER_Src/: delay.c
  group BSP_H
    ../USER_Inc/: delay.h
  group BSP_Task
    ../USER_Src/: main.c stm32f10x_it.c
  group Doc
    ../: readme.txt
